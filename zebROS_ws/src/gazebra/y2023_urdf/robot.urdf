Commit message: more code cleanup and add gazebra

File: zebROS_ws/src/gazebra/y2023_urdf/robot.urdf (robot description, URDF)
Before this commit: robot onshape, 14 links, 13 joints
Links:
- link central_chassis: mass 1.3606397467657669331 -> 7.7787891582795705148
